Commit message: Backup

File: gym_pybullet_drones/assets/hexp.urdf (robot description, URDF)
Before this commit: robot hexacopter, 8 links, 7 joints
Links:
- link base_link: mass 0.468 -> 3.752
